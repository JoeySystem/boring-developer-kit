#include "boring_5r_ui_core.h"

static const boring_5r_glyph_t kGlyphs[BORING_5R_GLYPH_COUNT] = {
    {0x20, 0, {0x00, 0x00, 0x00, 0x00, 0x00}},
    {0x41, 4, {0x06, 0x09, 0x0F, 0x09, 0x09}},
    {0x42, 4, {0x0E, 0x09, 0x0E, 0x09, 0x0E}},
    {0x43, 4, {0x07, 0x08, 0x08, 0x08, 0x07}},
    {0x44, 4, {0x0E, 0x09, 0x09, 0x09, 0x0E}},
    {0x45, 4, {0x0F, 0x08, 0x0E, 0x08, 0x0F}},
    {0x46, 4, {0x0F, 0x08, 0x0E, 0x08, 0x08}},
    {0x47, 4, {0x07, 0x08, 0x0B, 0x09, 0x07}},
    {0x48, 4, {0x09, 0x09, 0x0F, 0x09, 0x09}},
    {0x49, 3, {0x07, 0x02, 0x02, 0x02, 0x07}},
    {0x4A, 4, {0x03, 0x01, 0x01, 0x09, 0x06}},
    {0x4B, 4, {0x09, 0x0A, 0x0C, 0x0A, 0x09}},
    {0x4C, 4, {0x08, 0x08, 0x08, 0x08, 0x0F}},
    {0x4D, 5, {0x11, 0x1B, 0x15, 0x11, 0x11}},
    {0x4E, 4, {0x09, 0x0D, 0x0B, 0x09, 0x09}},
    {0x4F, 4, {0x06, 0x09, 0x09, 0x09, 0x06}},
    {0x50, 4, {0x0E, 0x09, 0x0E, 0x08, 0x08}},
    {0x51, 4, {0x06, 0x09, 0x09, 0x0B, 0x07}},
    {0x52, 4, {0x0E, 0x09, 0x0E, 0x0A, 0x09}},
    {0x53, 4, {0x07, 0x08, 0x06, 0x01, 0x0E}},
    {0x54, 5, {0x1F, 0x04, 0x04, 0x04, 0x04}},
    {0x55, 4, {0x09, 0x09, 0x09, 0x09, 0x06}},
    {0x56, 5, {0x11, 0x11, 0x11, 0x0A, 0x04}},
    {0x57, 5, {0x11, 0x11, 0x15, 0x1B, 0x11}},
    {0x58, 5, {0x11, 0x0A, 0x04, 0x0A, 0x11}},
    {0x59, 5, {0x11, 0x0A, 0x04, 0x04, 0x04}},
    {0x5A, 4, {0x0F, 0x01, 0x02, 0x04, 0x0F}},
    {0x30, 4, {0x06, 0x0B, 0x0D, 0x09, 0x06}},
    {0x31, 3, {0x02, 0x06, 0x02, 0x02, 0x07}},
    {0x32, 4, {0x0E, 0x01, 0x06, 0x08, 0x0F}},
    {0x33, 4, {0x0E, 0x01, 0x06, 0x01, 0x0E}},
    {0x34, 4, {0x09, 0x09, 0x0F, 0x01, 0x01}},
    {0x35, 4, {0x0F, 0x08, 0x0E, 0x01, 0x0E}},
    {0x36, 4, {0x07, 0x08, 0x0E, 0x09, 0x06}},
    {0x37, 4, {0x0F, 0x01, 0x02, 0x04, 0x04}},
    {0x38, 4, {0x06, 0x09, 0x06, 0x09, 0x06}},
    {0x39, 4, {0x06, 0x09, 0x07, 0x01, 0x0E}},
    {0x21, 1, {0x01, 0x01, 0x01, 0x00, 0x01}},
    {0x40, 5, {0x0E, 0x11, 0x17, 0x15, 0x0F}},
    {0x23, 5, {0x0A, 0x1F, 0x0A, 0x1F, 0x0A}},
    {0x24, 5, {0x0E, 0x14, 0x0E, 0x05, 0x1E}},
    {0x25, 5, {0x19, 0x1A, 0x04, 0x0B, 0x13}},
    {0x5E, 3, {0x02, 0x05, 0x00, 0x00, 0x00}},
    {0x26, 5, {0x0C, 0x10, 0x0D, 0x12, 0x0D}},
    {0x2A, 5, {0x15, 0x0E, 0x1F, 0x0E, 0x15}},
    {0x28, 2, {0x01, 0x02, 0x02, 0x02, 0x01}},
    {0x29, 2, {0x02, 0x01, 0x01, 0x01, 0x02}},
    {0x2B, 3, {0x02, 0x02, 0x07, 0x02, 0x02}},
    {0x2D, 3, {0x00, 0x00, 0x07, 0x00, 0x00}},
    {0x2F, 5, {0x01, 0x02, 0x04, 0x08, 0x10}},
    {0x2E, 1, {0x00, 0x00, 0x00, 0x00, 0x01}},
    {0x3D, 3, {0x00, 0x07, 0x00, 0x07, 0x00}},
};

static uint8_t normalize(uint8_t codepoint)
{
    return codepoint >= 'a' && codepoint <= 'z'
               ? (uint8_t)(codepoint - 'a' + 'A')
               : codepoint;
}

const boring_5r_glyph_t *boring_5r_find(uint8_t codepoint)
{
    codepoint = normalize(codepoint);
    for (size_t index = 0; index < BORING_5R_GLYPH_COUNT; ++index) {
        if (kGlyphs[index].codepoint == codepoint) {
            return &kGlyphs[index];
        }
    }
    return NULL;
}

int16_t boring_5r_measure(const char *text, uint8_t dot_diameter,
                          uint8_t center_pitch, uint8_t character_gap)
{
    if (text == NULL || *text == '\0') {
        return 0;
    }
    int16_t width = 0;
    for (size_t index = 0; text[index] != '\0'; ++index) {
        const boring_5r_glyph_t *glyph =
            boring_5r_find((uint8_t)text[index]);
        if (glyph == NULL) {
            return -1;
        }
        if (glyph->codepoint == ' ') {
            width += (int16_t)(2 * center_pitch);
        } else {
            width += (int16_t)((glyph->width - 1) * center_pitch +
                               dot_diameter);
            if (text[index + 1] != '\0') {
                width += character_gap;
            }
        }
    }
    return width;
}

bool boring_5r_draw(const char *text, int16_t x, int16_t y,
                    uint8_t dot_diameter, uint8_t center_pitch,
                    uint8_t character_gap, uint32_t color,
                    boring_5r_draw_dot_fn draw_dot, void *context)
{
    if (text == NULL || draw_dot == NULL) {
        return false;
    }
    int16_t cursor = x;
    for (size_t index = 0; text[index] != '\0'; ++index) {
        const boring_5r_glyph_t *glyph =
            boring_5r_find((uint8_t)text[index]);
        if (glyph == NULL) {
            return false;
        }
        if (glyph->codepoint == ' ') {
            cursor += (int16_t)(2 * center_pitch);
            continue;
        }
        for (uint8_t row = 0; row < BORING_5R_ROWS; ++row) {
            for (uint8_t column = 0; column < glyph->width; ++column) {
                const uint8_t bit =
                    (uint8_t)(1U << (glyph->width - 1U - column));
                if ((glyph->rows[row] & bit) != 0) {
                    draw_dot((int16_t)(cursor + dot_diameter / 2 +
                                       column * center_pitch),
                             (int16_t)(y + dot_diameter / 2 +
                                       row * center_pitch),
                             dot_diameter, color, context);
                }
            }
        }
        cursor += (int16_t)((glyph->width - 1) * center_pitch + dot_diameter);
        if (text[index + 1] != '\0') {
            cursor += character_gap;
        }
    }
    return true;
}
